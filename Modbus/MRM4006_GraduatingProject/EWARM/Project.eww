<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\MRM4006_GraduatingProject.ewp</path>
  </project>
  <batchBuild />
</workspace>
